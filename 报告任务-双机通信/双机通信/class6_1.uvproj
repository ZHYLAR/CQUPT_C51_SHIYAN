# Keil uVision project class6_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: class6_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c MatrixKey.c MatrixKey.h Delay.c Delay.h
